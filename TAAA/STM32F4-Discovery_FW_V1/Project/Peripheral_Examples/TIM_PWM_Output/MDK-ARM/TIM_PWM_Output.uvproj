# Keil uVision project TIM_PWM_Output.uvproj, settings and files
target TIM_PWM_Output (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TIM_PWM_Output
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: stm32f4xx_it.c system_stm32f4xx.c
    ./: PWM.c ADC.c DAC.c pi_c.c MAIN.c SPI.c pid_c.c pi_c_nr.c pid_c_nr.c dqe_transform.c trape.c NVIC.c rampgen.c sinemod.c dqs_trans.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_spi.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
